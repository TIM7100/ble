# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  AfterMake: fromelf -c -a -d -e -v -o simpleBlePeripheral.asm ./Objects/simpleBlePeripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\components\inc;..\components\ble\controller;..\components\osal\include;..\components\ble\include;..\components\ble\hci;..\components\ble\host;..\components\profiles\ota_app;..\components\profiles\DevInfo;..\components\profiles\SimpleProfile;..\components\profiles\Roles;.\source;..\components\libraries\crc16;..\components\driver\watchdog;..\components\driver\clock;..\components\driver\pwrmgr;..\components\driver\uart;..\components\driver\gpio;..\components\driver\timer;..\components\driver\log;..\components\driver\pwm;..\components\driver\flash;..\components\driver\led_light;..\components\libraries\fs;..\components\arch\cm0;..\misc;..\components\libraries\datetime;..\components\driver\key;..\components\driver\my_i2c;..\components\OTAEVENT
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x21000000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group lib
    ../lib/: rf.lib ble_host.lib
  group jump
    ../misc/: jump_table.c
  group driver
    ../components/driver/uart/: uart.c
    ../components/driver/clock/: clock.c
    ../components/driver/gpio/: gpio.c
    ../components/driver/timer/: timer.c
    ../components/driver/watchdog/: watchdog.c
    ../components/driver/pwrmgr/: pwrmgr.c
    ../components/driver/pwm/: pwm.c
    ../components/driver/flash/: flash.c
    ../components/driver/led_light/: led_light.c
    ../components/osal/snv/: osal_snv.c
    ../components/driver/log/: my_printf.c
    ../components/driver/my_i2c/: myi2c.c
    ../components/libraries/datetime/: app_datetime.c
    ../components/driver/key/: key.c
  group profile
    ../components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../components/profiles/GATT/: gattservapp.c
    ../components/profiles/ota_app/: ota_app_service.c
  group datahandle
    ../components/libraries/crc16/: crc16.c
  group BleUpgrader
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c file_handle.c random.c UpgraderHp9Serial.c aes.c sbpProfile_ota.c
  group OTAevent
    ../components/OTAEVENT/: otaevents.c otaevents.h ota_app_service1.c OTAfile_handle.c OTAfile_handle.h
  group ReadMe
    ./: readme.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
